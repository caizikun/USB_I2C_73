# IAR project USB_I2C_73.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L073xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: CMSIS; USER\Inc; FWlib\Inc; BSP; USB\USB_Config; USB\USB_Device_Library; HARDWARE\I2C; HARDWARE\ModSeLL; HARDWARE\max5417; HARDWARE\lpmode
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_I2C_20180802.hex
  ILINK.IlinkOutputFile: USB_I2C_73.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group BSP
    BSP/: stm32l0xx_nucleo.c
  group CMSIS
    CMSIS/startup/: startup_stm32l073xx.s
    CMSIS/: system_stm32l0xx.c
  group FWlib
    FWlib/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c
  group HARDWARE
    HARDWARE/I2C/: i2c.c soft_i2c.c
    HARDWARE/lpmode/: lpmode.c
    HARDWARE/max5417/: max5417.c
    HARDWARE/ModSeLL/: modsel.c
  group USB_Config
    USB/USB_Config/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group USB_Device_Library
    USB/USB_Device_Library/: usbd_cdc.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USER
    USER/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
